File: ESP32S3PCM5122/OPA1656-POWER.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U3 OPA1656

Commit message: more
Other:
- moved on the sheet: C2, PS1, U3C
